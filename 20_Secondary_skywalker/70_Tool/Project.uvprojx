# Keil uVision project Project.uvprojx, settings and files
target Skywalker_Sec (5060183::V5.06 update 2 (build 183)::.\ARM_Compiler_5.06u2)
  device: STM32F334C6Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Skywalker_4000W_Sec_V +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F334x6, ARM_MATH_CM4, __FPU_PRESENT = 1, __FPU_USED = 1
  c include: ..\30_Bsw\adc;..\30_Bsw\clock;..\30_Bsw\common;..\30_Bsw\comp;..\30_Bsw\crc;..\30_Bsw\dac;..\30_Bsw\exti;..\30_Bsw\flash;..\30_Bsw\hrtimer;..\30_Bsw\hwio;..\30_Bsw\iohw;..\30_Bsw\main;..\30_Bsw\port;..\30_Bsw\rte;..\30_Bsw\schm;..\30_Bsw\timer;..\30_Bsw\trap;..\30_Bsw\uart;..\30_Bsw\uartprt;..\30_Bsw\wdg;..\40_Appl\acsctrl;..\40_Appl\intcom;..\40_Appl\llcctrl;..\40_Appl\meter;..\40_Appl\monctrl;..\40_Appl\tempctrl;..\40_Appl\tmctrl;..\50_Lib\mathlib;..\50_Lib\driverlib;..\50_Lib\Assembly;..\50_Lib\Core_Lib;..\50_Lib\ARM_Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: Project.sct
  group Libraries
    ../50_Lib/driverlib/: StdPeriphDriver.c
    ../50_Lib/Assembly/: ccram_vector_table.s startup_stm32f334x8.s
    ../50_Lib/mathlib/: mathlib.c
  group 30_Bsw
    ../30_Bsw/adc/: adc.c
    ../30_Bsw/clock/: clock.c
    ../30_Bsw/comp/: comp.c
    ../30_Bsw/crc/: crc.c
    ../30_Bsw/dac/: dac.c
    ../30_Bsw/exti/: exti.c
    ../30_Bsw/flash/: flash.c
    ../30_Bsw/hrtimer/: hrtimer.c
    ../30_Bsw/hwio/: hwio.c
    ../30_Bsw/main/: main.c
    ../30_Bsw/port/: port.c
    ../30_Bsw/rte/: rte.c
    ../30_Bsw/schm/: schm.c
    ../30_Bsw/timer/: timer.c
    ../30_Bsw/uart/: uart.c
    ../30_Bsw/uartprt/: uartprt.c
    ../30_Bsw/wdg/: wdg.c
  group 40_Appl
    ../40_Appl/acsctrl/: acsctrl.c
    ../40_Appl/intcom/: intcom.c
    ../40_Appl/llcctrl/: llcctrl.c
    ../40_Appl/meter/: meter.c
    ../40_Appl/monctrl/: monctrl.c
    ../40_Appl/tempctrl/: tempctrl.c
    ../40_Appl/tmctrl/: tmctrl.c
  group Appendix
    ../20_Make/: Appendix.txt
target Skywalker_Sec_Halt (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F334C6 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Skywalker_4000W_Sec_Halt +hex
  c flags: oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F334x6, ARM_MATH_CM4, __FPU_PRESENT = 1, __FPU_USED = 1, HALT_TEST_MODE = 1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8002100 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  scatter file: Project.sct
