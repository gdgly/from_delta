# Keil uVision project Project.uvprojx, settings and files
target Skywalker_4000W_Com (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F071C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Skywalker_4000W_Com_V +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F051
  c include: ..\30_Bsw\adc;..\30_Bsw\clock;..\30_Bsw\common;..\30_Bsw\flash;..\30_Bsw\main;..\30_Bsw\port;..\30_Bsw\pwm;..\30_Bsw\rte;..\30_Bsw\schm;..\30_Bsw\timer;..\30_Bsw\wdg;..\30_Bsw\i2c;..\30_Bsw\eeprom;..\30_Bsw\crc;..\30_Bsw\common;..\30_Bsw\cali;..\30_Bsw\hwio;..\30_Bsw\rtc;..\30_Bsw\buffer;..\30_Bsw\uart;..\30_Bsw\i2cprt;..\30_Bsw\mem;..\30_Bsw\uartprt;..\30_Bsw\dam;..\40_Appl\tempctrl;..\40_Appl\monctrl;..\40_Appl\timectrl;..\40_Appl\psuctrl;..\40_Appl\intcom;..\40_Appl\pmbus;..\40_Appl\calctrl;..\40_Appl\fanctrl;..\40_Appl\tmctrl;..\40_Appl\blabox;..\40_Appl\ledctrl;..\50_Lib\driverlib;..\50_Lib\ARM_Lib;..\50_Lib\Core_Lib;..\50_Lib\Assembly
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: Project.sct
  group Libraries
    ../50_Lib/driverlib/: StdPeriphDriver.c
    ../50_Lib/Assembly/: startup_stm32f0xx.s
  group 30_Bsw
    ../30_Bsw/adc/: adc.c
    ../30_Bsw/buffer/: buffer.c
    ../30_Bsw/clock/: clock.c
    ../30_Bsw/eeprom/: eeprom.c
    ../30_Bsw/flash/: flash.c
    ../30_Bsw/main/: main.c
    ../30_Bsw/port/: port.c
    ../30_Bsw/pwm/: pwm.c
    ../30_Bsw/rte/: rte.c
    ../30_Bsw/schm/: schm.c
    ../30_Bsw/timer/: timer.c
    ../30_Bsw/wdg/: wdg.c
    ../30_Bsw/crc/: crc.c
    ../30_Bsw/i2c/: i2c.c
    ../30_Bsw/rtc/: rtc.c
    ../30_Bsw/cali/: cali.c
    ../30_Bsw/uart/: uart.c
    ../30_Bsw/i2cprt/: i2cprt.c
    ../30_Bsw/mem/: mem.c
    ../30_Bsw/hwio/: hwio.c
    ../30_Bsw/uartprt/: uartprt.c
    ../30_Bsw/dam/: s_dam.c
  group 40_Appl
    ../40_Appl/pmbus/: pmbus.c
    ../40_Appl/fanctrl/: fanctrl.c
    ../40_Appl/monctrl/: monctrl.c
    ../40_Appl/psuctrl/: psuctrl.c
    ../40_Appl/tempctrl/: tempctrl.c
    ../40_Appl/ledctrl/: ledctrl.c
    ../40_Appl/timectrl/: timectrl.c
    ../40_Appl/intcom/: intcom.c
    ../40_Appl/blabox/: blabox.c
  group Appendix
    ../20_Make/: Appendix.txt i2c file back up.txt
target Skywalker_4000W_Com_Halt (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F071CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Skywalker_4000W_Com_V_HALT +hex
  c flags: oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F051,EXTERNAL_OSCILLATOR,HALT_TEST_MODE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: Project.sct
